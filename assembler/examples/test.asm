
.board=PLC14500-Nano

.io_SWITCH=IN0
.io_LIGHT=OUT0
.io_FAN=OUT1
.io_FANTON=SPR0
.io_FANTOFF=SPR1

IEN  IN6
OEN  IN6

LD SWITCH
STO LIGHT

ANDC FANTON
STO TMR0-TRIG
SKZ
STO FANTON

LDC TMR0-OUT
AND FANTON
SKZ
STO FAN

LDC SWITCH
AND FANTON
ANDC FANTOFF
ANDC TMR0-OUT
STO TMR0-TRIG
SKZ
STO FANTOFF

LDC FANTOFF
SKZ
JMP 0

LD TMR0-OUT
SKZ
JMP 0

STO FAN
STO FANTON
STO FANTOFF

JMP 0





